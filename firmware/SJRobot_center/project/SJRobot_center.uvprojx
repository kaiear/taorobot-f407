# Keil uVision project SJRobot_center.uvprojx, settings and files
target SJRobot_center (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.8.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SJRobot_center +hex
  c flags: Optim=2 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,USE_USB_OTG_FS
  c include: ..\CORE;..\Drive_include;..\DSP_LIB\Include;..\FWLIB\inc;..\Hardware_include;..\Motorcontrol_include;..\User_include;..\SRC;..\USB\USB_APP;..\USB\USB_HOST_CLASS\HID\inc;..\USB\USB_HOST_CODE\inc;..\USB\USB_HOST_DRIVER\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --entry Reset_Handler --first __Vectors
  group CORE
    ../CORE/: stm32f4xx_it.c system_stm32f4xx.c startup_stm32f40_41xxx.s
  group DSP_LIB
    ../DSP_LIB/: arm_cortexM4lf_math.lib
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_dma.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_dac.c stm32f4xx_exti.c
  group USB_HOST_CODE
    ../USB/USB_HOST_CODE/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
  group USB_HOST_DRIVER
    ../USB/USB_HOST_DRIVER/src/: usb_hcd_int.c usb_hcd.c usb_core.c
  group USB_HOST_CLASS
    ../USB/USB_HOST_CLASS/HID/src/: usbh_hid_core.c usbh_hid_gamepad.c usbh_hid_keybd.c usbh_hid_mouse.c
  group USB_APP
    ../USB/USB_APP/: usb_bsp.c usbh_usr.c
  group Drive_program
    ../Drive_program/: GPIO_int.c Sys.c can.c uart1.c uart2.c tao_protocol_v2.c y_zx_uart3.c
  group Hardware_program
    ../Hardware_program/: y_beep.c y_inv_mpu.c y_inv_mpu_dmp_motion_driver.c y_motor.c y_mpu6050.c y_myiic.c y_sbus.c y_spwm.c y_switch.c y_servo.c
  group Motorcontrol_program
    ../Motorcontrol_program/: Common_Math.c kinematics.c robot.c
  group User_program
    ../User_program/: main.c Task_manager.c y_global.c app_ps2.c
